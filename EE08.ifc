Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
Time: Wed Aug 12 17:17:32 2020
Author: at3107
Written by: PTC Creo 1.0
Made in: PTC

# IfcProject, Default Project
LongName: Project Status; Phase: Project Status

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: Part, EE08
In: Default Storey
PTC_Identity Data - DEVICENAME: High Precision Humidity and Temperature Probe; MEASURAND1: Relative humidity; Measuring range 0…100 %; MEASURAND2: Temperature; Measuring range -40…80 °C (-40... 176 °F); OUTPUT1: Analogue voltage; 0 - 1 / 2.5 / 5 / 10 V; OUTPUT2: Analogue voltage; 0 - 1 / 2.5 / 5 / 10 V; OUTPUT3: Digital interface; RS485 with E2; SUPPLY: 0-1V /0-2.5V: 4.5-15V DC or 7-30V DC; 0-5V: 7-30V DC; 0-10V: 12-30V DC; ENCLOSUREMATERIAL: Probe: Polycarbonate / IP65 Cable: PVC; ENCLOSUREDIMENSIONS: Probe: Ø 12 mm (0.47"), 73 mm (2.9”) Cable: up to 5 m (16.4ft); VOLUME: 8699.32; SURFACE_AREA: 3409.41; MASS: 8699.32; DENSITY: 1; CENTRE_OF_GRAVITY_X: 0; CENTRE_OF_GRAVITY_Y: 0; CENTRE_OF_GRAVITY_Z: 19.8243
